# Keil uVision project v1.1.0.20250531_base.uvprojx, settings and files
target v1.1.0.20240531_base (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: v1.1.0.20250531_base +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CORE;..\SYSTEM;..\HARDWARE;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/: delay.c delay.h timer.c timer.h
  group HARDWARE
    ../HARDWARE/: led.c led.h motor.c motor.h pwm.c pwm.h usart1.c usart1.h hcsr04.c hcsr04.h
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
